# Keil uVision project stm32_project.uvproj, settings and files
target stm32 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_project
  c flags: Optim=1
  c define: STM32F10X_HD USE_STDPERIPH_DRIVER
  c include: ./StdPeriph/inc/;./CMSIS/;./App/;./FreeRTOS/include/;./FreeRTOS/portable/RVDS/ARM_CM3/;./emWin/Include;./drivers;./emWin_port
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
  group StdPeriph
    ./StdPeriph/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
  group CMSIS
    ./CMSIS/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
  group App
    ./App/: main.c
  group FreeRTOS
    ./FreeRTOS/: list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_2.c
  group emWin_Inc
    ./emWin/Include/: BUTTON.h CHECKBOX.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h EDIT.h FRAMEWIN.h Global.h GRAPH.h GUI.h GUI_ARRAY.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_HOOK.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIConf.h GUIDRV_BitPlains.h GUIDRV_DCache.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_Generic.h GUIDRV_IST3088.h GUIDRV_Lin.h GUIDRV_NoOpt_1_8.h GUIDRV_S1D15G00.h GUIDRV_S1D13748.h GUIDRV_SLin.h GUIDRV_SPage.h GUIDRV_SSD1926.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h HEADER.h ICONVIEW.h IMAGE.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LCDConf.h LISTBOX.h LISTVIEW.h LISTWHEEL.h MENU.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h PROGBAR.h RADIO.h SCROLLBAR.h SLIDER.h SPINBOX.h TEXT.h TREEVIEW.h WIDGET.h WM.h WM_GUI.h WM_Intern.h
  group emWin_Lib
    ./emWin/Lib/: GUI_CM3.lib
  group emWin_port
    ./emWin_port/: GUI_X.c LCDConf.c GUIConf.c
  group drivers
    ./drivers/: crc8.c ds18b20.c onewire.c rtc.c lcd_drv.c
